# Keil uVision project Infantry.uvprojx, settings and files
target Infantry (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Infantry
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c misc: --C99
  c include: ../Inc;    ../Drivers/STM32F4xx_HAL_Driver/Inc;    ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Include;    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;    ..\CONTROL\Control;    ..\CONTROL\Ctrl_Chassis;    ..\CONTROL\Ctrl_Cloud;    ..\CONTROL\Ctrl_Frict;    ..\CONTROL\Ctrl_Rammer;    ..\DRIVER\Driver_DBUS;    ..\DRIVER\Driver_Display;    ..\DRIVER\Driver_Hierogram;    ..\DRIVER\Driver_Judge;    ..\DRIVER\Driver_PID;    ..\USER\User_Can;    ..\USER\User_GPIO;    ..\USER\User_TIM;    ..\USER\User_USART;    ..\USER\User;    ..\DRIVER\Driver;    ..\DRIVER\Driver_Gyro;    ..\DRIVER\Dirver_OLED;    ..\DRIVER\Driver_Niming;    ..\CONTROL\Ctrl_Chassis;    ..\DRIVER\Driver_SupCap;    ..\USER\User_ADC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User
    ../Src/: main.c dma.c can.c i2c.c spi.c tim.c usart.c gpio.c stm32f4xx_it.c stm32f4xx_hal_msp.c adc.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma.c stm32f4xx_hal_cortex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_adc.c
  group User
    ../USER/User/: User.c
    ../USER/User_TIM/: User_TIM.c
    ../USER/User_GPIO/: User_GPIO.c
    ../USER/User_USART/: User_USART.c
    ../USER/User_CAN/: User_CAN.c
    ../USER/User_ADC/: User_ADC.c
  group Driver
    ../DRIVER/Driver/: Driver.c
    ../DRIVER/Driver_PID/: Driver_PID.c
    ../DRIVER/Driver_DBUS/: Driver_DBUS.c
    ../DRIVER/Driver_Judge/: Driver_Judge.c
    ../DRIVER/Driver_Display/: Driver_Display.c
    ../DRIVER/Driver_Hierogram/: Driver_Hierogram.c
    ../DRIVER/Driver_Gyro/: Driver_Gyro.c
    ../DRIVER/Dirver_OLED/: Dirver_OLED.c
    ../DRIVER/Driver_Niming/: Driver_Niming.c
    ../DRIVER/Driver_SupCap/: Driver_SupCap.c
  group Control
    ../CONTROL/Control/: control.c
    ../CONTROL/Ctrl_Rammer/: Ctrl_Rammer.c
    ../CONTROL/Ctrl_Chassis/: Ctrl_Chassis.c
    ../CONTROL/Ctrl_Cloud/: Ctrl_Cloud.c
    ../CONTROL/Ctrl_Frict/: Ctrl_Frict.c
software components: CMSIS:CORE 5.1.1
